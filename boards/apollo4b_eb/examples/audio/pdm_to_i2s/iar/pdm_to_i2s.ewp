# IAR project pdm_to_i2s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; __FPU_PRESENT; AM_PART_APOLLO4B; UNITY_INCLUDE_CONFIG_H; AM_UTIL_FAULTISR_PRINT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\utils; ..\src; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\boards\apollo4b_eb\bsp; ..\..\..\..\..\..\third_party\SEGGER\SEGGER_RTT_V680a\RTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: pdm_to_i2s.bin
  ILINK.IlinkOutputFile: pdm_to_i2s.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\CMSIS\ARM\Lib\ARM\iar_cortexM4lf_math.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\boards\apollo4b_eb\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; __FPU_PRESENT; AM_PART_APOLLO4B; UNITY_INCLUDE_CONFIG_H; AM_UTIL_FAULTISR_PRINT
  group (top)
    ../src/: am_i2s_ring_buffer.c am_resources.c pdm_to_i2s.c
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../../third_party/SEGGER/SEGGER_RTT_V680a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./: startup_iar.c

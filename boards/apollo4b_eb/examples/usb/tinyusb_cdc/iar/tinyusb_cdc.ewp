# IAR project tinyusb_cdc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4B; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\tinyusb\src\class\cdc; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\tinyusb\src; ..\src; ..\..\..\..\..\..\third_party\tinyusb\src\osal; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\tinyusb\src\common; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tinyusb_cdc.bin
  ILINK.IlinkOutputFile: tinyusb_cdc.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4B; AM_PACKAGE_BGA; CFG_TUSB_MCU=OPT_MCU_APOLLO4
  group (top)
    ../../../../../../third_party/tinyusb/src/portable/ambiq/apollo4/: dcd_apollo4.c
    ../../../../../../third_party/tinyusb/src/device/: usbd.c usbd_control.c
    ../../../../../../third_party/tinyusb/src/: tusb.c
    ../src/: am_resources.c apollo4_board.c main.c usb_descriptors.c
    ../../../../../../third_party/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ../../../../../../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ./: startup_iar.c

# Keil uVision project nemagfx_gauge.uvprojx, settings and files
target nemagfx_gauge (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_gauge
  AfterMake: fromelf --bin --output bin\nemagfx_gauge.bin bin\nemagfx_gauge.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_gauge.txt bin\nemagfx_gauge.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA PLATFORM=apollo4b_nemagfx LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib AM_FREERTOS USE_TSI_MALLOC AM_PART_APOLLO4B NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK keil
  c include: ../../../../bsp;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../utils;../src;../../../../../..;../../../../../../devices;../src/generated;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../src/generated/assets/fonts;../../../../../../mcu/apollo4b/hal;../../../../../../mcu/apollo4b;../../../../../../third_party/FreeRTOSv10.1.1/Source/include;../src/generated/NemaGUI;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../src/generated/assets/images;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2;../../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group FreeRTOSv10.1.1_AMapollo2
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/Keil/AMapollo2/: port.c
  group src
    ../src/: am_resources.c gui_task.c nemagfx_gauge.c rtos.c
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group NemaGUI
    ../src/generated/NemaGUI/: main.c
  group FreeRTOSv10.1.1_Source
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
  group FreeRTOSv10.1.1_MemMang
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib

# Keil uVision project nemagfx_rotating_clock.uvprojx, settings and files
target nemagfx_rotating_clock (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: nemagfx_rotating_clock
  AfterMake: fromelf --bin --output bin\nemagfx_rotating_clock.bin bin\nemagfx_rotating_clock.axf
  AfterMake: fromelf -cedrst --output bin\nemagfx_rotating_clock.txt bin\nemagfx_rotating_clock.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO4B USE_TSI_MALLOC NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK AM_PACKAGE_BGA PLATFORM=apollo4b_nemagfx BAREMETAL LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib keil
  c include: ../../../../../../CMSIS/ARM/Include;../../../../../../third_party/ThinkSi/NemaGFX_SDK/common/mem;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaGFX;../../../../../..;../../../../../../third_party/ThinkSi/NemaGFX_SDK/NemaDC;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/common;../../../../../../devices;../../../../../../utils;../../../../bsp;../../../../../../mcu/apollo4b/hal;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaGFX;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx;../../../../../../third_party/ThinkSi/NemaGFX_SDK/include/tsi/NemaDC;../../../../../../mcu/apollo4b;../src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c main.c nemagfx_rotating_clock.c
  group ThinkSi_apollo4b_nemagfx
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/keil/bin/: lib_nema_apollo4b_nemagfx.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
